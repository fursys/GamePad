# IAR project STM32_GamePad.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: C:\skuksenk\_Quadro\ARM\prj\lib\FreeRTOS\Source\include; ; C:\skuksenk\_Quadro\ARM\prj\lib\FreeRTOS\Source\portable\IAR\ARM_CM3; C:\skuksenk\_Quadro\ARM\prj\lib\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc; C:\skuksenk\_Quadro\ARM\prj\lib\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; USB_Proc\inc; C:\skuksenk\_Quadro\ARM\prj\lib\STM32_USB-FS-Device_Lib_V3.4.0\Libraries\STM32_USB-FS-Device_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: STM32_GamePad.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: STM32F103C8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: ADC.c flash.c main.c stm32f10x_it.c XBEE.c
  group CMSIS
    ../lib/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    ../lib/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group FreeRTOS
    ../lib/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../lib/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../lib/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group StdPerifDriver
    ../lib/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group USB_Driver
    ../lib/STM32_USB-FS-Device_Lib_V3.4.0/Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_Proc
    USB_Proc/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
